# Repository radioelf/Int-out-PCB

File README.md:

# In-out-PCB
PCB for control of 8 inputs, 2 dimmers and 8 relay outputs 

Kicad Application:
Version: 6.99.0-unknown-f8b157a1fb-149-ubuntu22.04.1, release build

Correcciones:
Version: 7.99.0-unknown-e60837ec95-170~ubuntu22.04.1, release build

## KiCad design int_out.kicad_pcb

Parts:
C1, C2, C3, C4: 4.7uF; CP_Elec_4x3.9
C5: 22uF; CP_Elec_4x5.8
C6, C7: 100nF; C_0805_2012Metric
C8: 100nF 400V; C_Disc_D16.0mm_W5.0mm_P10.00mm
C9: 220uF; CP_Elec_5x4.4
D1: LED; LED_0805_2012Metric
F1: 500mA; Fuse_Littelfuse_372_D8.50mm
H1: +5v; Pin_D1.0mm_L10.0mm
H2: GND; Pin_D1.0mm_L10.0mm
H3: Line; Pin_D1.0mm_L10.0mm
H4: Neut; Pin_D1.0mm_L10.0mm
J1: Dimmers; TerminalBlock_4Ucon_1x03_P3.50mm_Horizontal
J2: Relays; PhoenixContact_MCV_1,5_16-GF-3.5_1x16_P3.50mm_Vertical_Thre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
J3: switch inputs; PhoenixContact_MCV_1,5_5-G-3.5_1x05_P3.50mm_Vertical
J4: Inputs power 230V ac; PhoenixContact_MCV_1,5_4-G-3.5_1x04_P3.50mm_Vertical
J5: Power 230V ac; PhoenixContact_MCV_1,5_3-G-3.5_1x03_P3.50mm_Vertical
JP1: Boot; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
JP2: Reset; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
K1, K2, K3, K4, K5, K6, K7, K8: HF49FD-005-1H11; Relay_HF49FDxxx-1h1
PS1: Module 230Vac-5Vdc 2A; Converter_ACDC_HiLink_HLK-PMxx
Q1, Q2: TIC226; TO-220-3_Vertical
R1, R2: 330R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R5: 360R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 150R; R_0805_2012Metric
R6, R11, R16, R17, R18, R21, R23, R24, R25, R30: 4k7; R_0805_2012Metric
R7, R8: 220R; R_0805_2012Metric
R9, R10: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R12, R13, R14, R15, R19: 10K; R_0805_2012Metric
R20: 330R; R_0805_2012Metric
R22: 100; R_0805_2012Metric
R26, R27, R28, R29: 220K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
SW1: SWx4
TP1: RXD; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP2: TXD; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP3: Aux.; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
U1: H11AA1; DIP-6_W7.62mm_SMDSocket_SmallPads
U2, U3: MOC3041M; DIP-6_W7.62mm_LongPads
U4: ESP32-WROOM-32UE; ESP32-WROOM-32U
U5: LM1117-3.3; SOT-223-3_TabPin2
U6: TLP291-4; SOIC-16_4.55x10.3mm_P1.27mm
U7: ULN2803A; SOIC-18W_7.5x11.6mm_P1.27mm
U8: TLP290-4; DIP-16_W7.62mm

Connections:
+3V3: C5.1, C6.1, R6.2, R11.1, R12.2, R13.2, R14.2, R15.2, R16.1, R17.1, R18.1, R19.1, R30.2, U4.2 (VDD), U5.2 (VO)
+5V: C7.1, C9.1, H1.1, K1.2, K2.2, K3.2, K4.2, K5.2, K6.2, K7.2, K8.2, PS1.4 (+Vout), R22.2, U5.3 (VI), U7.10 (COM)
Earth: J5.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, H2.1, J3.1, JP1.2, JP2.2, PS1.3 (-Vout), R20.2, U1.4, U2.2, U3.2, U4.1 (GND), U4.15 (GND), U4.38 (GND), U4.39 (GND), U5.1 (GND), U6.9, U6.11, U6.13, U6.15, U7.9 (GND), U8.9, U8.11, U8.13, U8.15
LINE: F1.2, J1.3, J5.1, Q1.2 (A2), Q2.2 (A2), R3.2, R5.2, R9.2
NEUT: C8.2, H4.1, J5.3, PS1.2 (AC/N), R10.2
unnamed: C8.1, U8.1, U8.3, U8.5, U8.7
unnamed: D1.2 (A), U4.14 (IO12)
unnamed: D1.1 (K), R20.1
unnamed: J1.1, Q1.1 (A1), R2.2
unnamed: J1.2, Q2.1 (A1), R1.2
unnamed: J2.1, K8.4
unnamed: J2.2, K8.3
unnamed: J2.3, K7.4
unnamed: J2.4, K7.3
unnamed: J2.5, K6.4
unnamed: J2.6, K6.3
unnamed: J2.7, K5.4
unnamed: J2.8, K5.3
unnamed: J2.9, K4.4
unnamed: J2.10, K4.3
unnamed: J2.11, K3.4
unnamed: J2.12, K3.3
unnamed: J2.13, K2.4
unnamed: J2.14, K2.3
unnamed: J2.15, K1.4
unnamed: J2.16, K1.3
unnamed: J3.2, R21.2
unnamed: J3.3, R23.2
unnamed: J3.4, R24.2
unnamed: J3.5, R25.2
unnamed: J4.1, R26.1
unnamed: J4.2, R27.1
unnamed: J4.3, R28.1
unnamed: J4.4, R29.1
unnamed: F1.1, H3.1, PS1.1 (AC/L)
unnamed: Q1.3 (G), R2.1, U3.4
unnamed: Q2.3 (G), R1.1, U2.4
unnamed: R3.1, U3.6
unnamed: R4.2, U1.5
unnamed: R5.1, U2.6
unnamed: R7.2, U3.1
unnamed: R8.2, U2.1
unnamed: R9.1, U1.1
unnamed: R10.1, U1.2
unnamed: R21.1, U6.2
unnamed: R22.1, U6.1, U6.3, U6.5, U6.7
unnamed: R23.1, U6.4
unnamed: R24.1, U6.6
unnamed: R25.1, U6.8
unnamed: R26.2, U8.2
unnamed: R27.2, U8.4
unnamed: R28.2, U8.6
unnamed: R29.2, U8.8
unnamed: JP2.1, R19.2, U4.3 (EN)
unnamed: JP1.1, U4.25 (IO0)
unnamed: C1.1, R12.1, U4.24 (IO2), U8.16
unnamed: C2.1, R13.1, U4.26 (IO4), U8.14
unnamed: C3.1, R14.1, U4.29 (IO5), U8.12
unnamed: C4.1, R15.1, U4.16 (IO13), U8.10
unnamed: R11.2, U4.13 (IO14), U6.16
unnamed: R16.2, U4.23 (IO15), U6.14
unnamed: R17.2, U4.27 (IO16), U6.12
unnamed: R18.2, U4.28 (IO17), U6.10
unnamed: U4.30 (IO18), U7.8 (I8)
unnamed: U4.31 (IO19), U7.7 (I7)
unnamed: U4.33 (IO21), U7.6 (I6)
unnamed: U4.36 (IO22), U7.5 (I5)
unnamed: U4.37 (IO23), U7.4 (I4)
unnamed: U4.10 (IO25), U7.3 (I3)
unnamed: U4.11 (IO26), U7.2 (I2)
unnamed: U4.12 (IO27), U7.1 (I1)
unnamed: R7.1, U4.8 (IO32)
unnamed: R8.1, U4.9 (IO33)
unnamed: R30.1, TP3.1, U4.6 (IO34)
unnamed: R4.1, R6.1, U4.7 (IO35)
unnamed: TP1.1, U4.34 (RXD0/IO3)
unnamed: TP2.1, U4.35 (TXD0/IO1)
unnamed: K1.1, U7.18 (O1)
unnamed: K2.1, U7.17 (O2)
unnamed: K3.1, U7.16 (O3)
unnamed: K4.1, U7.15 (O4)
unnamed: K5.1, U7.14 (O5)
unnamed: K6.1, U7.13 (O6)
unnamed: K7.1, U7.12 (O7)
unnamed: K8.1, U7.11 (O8)

Board: 2 copper layers, 85.3 x 100.1 mm, 73 parts (0 on the bottom side), 85 nets.

## Commit log

2022-08-25 Files gerber
2023-02-17 Correcciones
2023-03-16 bug fix in U5 (LM1117-3.3)
